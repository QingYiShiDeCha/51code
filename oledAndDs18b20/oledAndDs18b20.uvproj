# Keil uVision project oledAndDs18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: oledAndDs18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\public;.\app\ds18b20;.\app\oled
  group Source Group 1
    ./: STARTUP.A51
    ./user/: main.c
    ./public/: public.c
    ./app/ds18b20/: ds18b20.c
    ./app/oled/: oled.c
